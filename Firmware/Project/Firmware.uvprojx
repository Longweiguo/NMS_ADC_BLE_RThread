# Keil uVision project Firmware.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AM_PACKAGE_BGA
  c include: ..\Source;..\Source\utils;..\Source\bsp_3p;..\Source\bsp_3p\regs;..\Source\bsp_3p\hal
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  group Source Group 1
    ../Source/: main.c startup_apollo3p.s am_bsp_pins.c am_bsp.c ad7147.c heyos_hal_adc.c heyos_hal_spi.c heyos_hal_nand.c
    ../Source/utils/: am_util_stdio.c
  group MCULib
    ../Source/bsp_3p/hal/: am_hal_uart.c am_hal_queue.c am_hal_reset.c am_hal_pwrctrl.c am_hal_mspi.c am_hal_clkgen.c am_hal_gpio.c am_hal_mcuctrl.c am_hal_interrupt.c am_hal_flash.c am_hal_cmdq.c am_hal_cachectrl.c am_hal_rtc.c am_hal_itm.c am_hal_tpiu.c am_hal_adc.c am_hal_iom.c am_hal_burst.c
software components: CMSIS:CORE 5.5.0
